## base_external/package/aesd_project/Config.in
```kconfig
config BR2_PACKAGE_AESD_PROJECT
	bool "aesd_project"
	help
	  Includes I2C and socket code for RPi
```
